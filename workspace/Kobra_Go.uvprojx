# Keil uVision project Kobra_Go.uvprojx, settings and files
target Gorilla_Go_Firmware (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32F460KETA HDSC
  pack: HDSC.HC32F460.1.0.11
  cpu: IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) IROM(0x00000000,0x80000) IROM2(0x03000C00,0x003FC) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: firmware +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: HC32F46x,USE_DEVICE_DRIVER_LIB,__TARGET_FPU_VFP,__FPU_PRESENT=1,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__MPU_PRESENT=1,STM32_HIGH_DENSITY,ARDUINO_ARCH_STM32F1,ARDUINO_ARCH_STM32
  c misc: --gnu --diag_suppress=186,66 --cpp11 --multifile --no-multibyte-chars
  c include: ..\source\compoment\adc;..\source\compoment\i2c;..\source\compoment\sdio;..\source\compoment\sdio\sd_card\inc;..\source\compoment\spi;..\source\compoment\uart;..\source\compoment\Utility;..\source\drivers\board;..\source\drivers\library;..\source\drivers\library\inc;..\source\framework\cores;..\source\framework\usb;..\source\framework\variants;..\source\main;..\source\main\hdsc32core;..\source\marlin;..\source\marlin\src;..\source\marlin\src\pins;..\source\marlin\src\core;..\source\marlin\src\feature;..\source\marlin\src\feature\bedlevel;..\source\marlin\src\feature\bedlevel\abl;..\source\marlin\src\feature\bedlevel\mbl;..\source\marlin\src\feature\bedlevel\ubl;..\source\marlin\src\feature\digipot;..\source\marlin\src\feature\leds;..\source\marlin\src\feature\mmu;..\source\marlin\src\feature\password;..\source\marlin\src\gcode;..\source\marlin\src\HAL;..\source\marlin\src\HAL\shared;..\source\marlin\src\HAL\shared\backtrace;..\source\marlin\src\HAL\STM32;..\source\marlin\src\HAL\STM32\tft;..\source\marlin\src\HAL\STM32\inc;..\source\marlin\src\inc;..\source\marlin\src\lcd;..\source\marlin\src\lcd\dogm;..\source\marlin\src\lcd\dogm\fontdata;..\source\marlin\src\lcd\dwin;..\source\marlin\src\lcd\language;..\source\marlin\src\lcd\menu;..\source\marlin\src\lcd\menu\game;..\source\marlin\src\libs;..\source\marlin\src\module;..\source\marlin\src\module\stepper;..\source\marlin\src\module\thermistor;..\source\marlin\src\pins;..\source\marlin\src\pins\stm32f1;..\source\marlin\src\sd;..\source\marlin\src\sd\usb_flashdrive;..\source\marlin\src\sd\usb_flashdrive\lib-uhs2;..\source\marlin\src\lcd\extui;..\source\marlin\src\lcd\extui\lib\anycubic;..\source\marlin\src\lcd\extui\lib\dgus;..\source\marlin\src\lcd\extui\lib\dgus\fysetc;..\source\marlin\src\lcd\extui\lib\dgus\hiprecy;..\source\marlin\src\lcd\extui\lib\dgus\origin;..\source\marlin\src\lcd\extui\lib\ftdi_eve_touch_ui;..\source\marlin\src\lcd\extui\lib\ftdi_eve_touch_ui\archim2-flash;..\source\marlin\src\lcd\extui\lib\ftdi_eve_touch_ui\ftdi_eve_lib;..\source\marlin\src\lcd\extui\lib\ftdi_eve_touch_ui\ftdi_eve_lib\basic;..\source\marlin\src\lcd\extui\lib\ftdi_eve_touch_ui\ftdi_eve_lib\extended;..\source\marlin\src\lcd\extui\lib\ftdi_eve_touch_ui\ftdi_eve_lib\extended\unicode;..\source\marlin\src\lcd\extui\lib\ftdi_eve_touch_ui\ftdi_eve_lib\extras;..\source\marlin\src\lcd\extui\lib\ftdi_eve_touch_ui\language;..\source\marlin\src\lcd\extui\lib\ftdi_eve_touch_ui\screens;..\source\marlin\src\lcd\extui\lib\ftdi_eve_touch_ui\theme;..\source\marlin\src\lcd\extui\\lib\mks_ui;..\source\marlin\src\lcd\HD44780;..\source\marlin\src\sd\usb_flashdrive\lib-uhs3\dyn_SWI;..\source\marlin\src\sd\usb_flashdrive\lib-uhs3\UHS_host;..\source\marlin\src\sd\usb_flashdrive\lib-uhs3\UHS_host\UHS_BULK_STORAGE;..\source\marlin\src\sd\usb_flashdrive\lib-uhs3\UHS_host\USB_HOST_SHIELD;..\source\marlin\src\libs\heatshrink;..\source\marlin\src\libs\L64XX;..\source\marlin\src\lcd\dogm\status;..\source\marlin\src\lcd\dwin\e3v2;..\source\marlin\src\lcd\extui\lib\anycubic_chiron;..\source\marlin\src\lcd\extui\lib\anycubic_dgus;..\source\marlin\src\lcd\extui\lib\anycubic_i3mega;..\source\marlin\src\lcd\tft;..\source\marlin\src\lcd\tft_io;..\source\marlin\src\lcd\TFTGLCD;..\source\marlin\src\lcd\touch;..\source\marlin\src\module\stepper\source;..\source\framework\TMCStepper;..\source\framework\TMCStepper\source;..\source\arduino;..\source\board;..\source\FatFs;..\source\framework\SoftwareSerial;..\source\Marlin\src\lcd\tft_io;..\source\Marlin\src\lcd\tft;..\source\Marlin\src\lcd\tft\images;..\source\Marlin\src\lcd\tft\fontdata;..\source\Marlin\src\lcd\menu;..\source\Marlin\src\lcd\tft;..\source\Marlin\src\lcd\tft\fontdata;..\source\Marlin\src\lcd\tft\images;..\source\Marlin\src\lcd\tft_io;..\source\Marlin\src\lcd\language
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3fc
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20010000 size 0x10000
  link misc: --keep=*Handler
  group app
    ../source/app/: app_uart.cpp main.cpp
  group arduino
    ../source/arduino/: HardwareSerial.cpp HardwareSerial.h Print.cpp Print.h Printable.h Stream.cpp Stream.h WString.cpp WString.h
  group board
    ../source/board/: bsp_adc.cpp bsp_adc.h bsp_flash.cpp bsp_flash.h bsp_init.cpp bsp_init.h bsp_irq.cpp bsp_irq.h bsp_logo_data.h bsp_ots.cpp bsp_ots.h bsp_pwm.cpp bsp_pwm.h bsp_rmu.cpp bsp_rmu.h bsp_sdio.cpp bsp_sdio.h bsp_spi_tft.cpp bsp_spi_tft.h bsp_timer.cpp bsp_timer.h bsp_wdt.cpp bsp_wdt.h
  group compoment
    ../source/compoment/sdio/: sdio_hal.h
    ../source/compoment/sdio/sd_card/src/: sd_card.c sdmmc_cmd.c
    ../source/compoment/sdio/sd_card/inc/: sd_card.h sdmmc_cmd.h
  group drivers
    ../source/drivers/board/: board_gpio.c board_sdio.cpp board_sdio.h board_tim0.cpp startup.cpp board_adc.cpp board_adc.h
    ../source/drivers/library/src/: hc32f46x_adc.c hc32f46x_aes.c hc32f46x_can.c hc32f46x_clk.c hc32f46x_cmp.c hc32f46x_crc.c hc32f46x_dcu.c hc32f46x_dmac.c hc32f46x_efm.c hc32f46x_emb.c hc32f46x_event_port.c hc32f46x_exint_nmi_swi.c hc32f46x_gpio.c hc32f46x_hash.c hc32f46x_i2c.c hc32f46x_i2s.c hc32f46x_icg.c hc32f46x_interrupts.c hc32f46x_keyscan.c hc32f46x_mpu.c hc32f46x_ots.c hc32f46x_pwc.c hc32f46x_qspi.c hc32f46x_rmu.c hc32f46x_rtc.c hc32f46x_sdioc.c hc32f46x_spi.c hc32f46x_sram.c hc32f46x_swdt.c hc32f46x_timer0.c hc32f46x_timer4_cnt.c hc32f46x_timer4_emb.c hc32f46x_timer4_oco.c hc32f46x_timer4_pwm.c hc32f46x_timer4_sevt.c hc32f46x_timer6.c hc32f46x_timera.c hc32f46x_trng.c hc32f46x_usart.c hc32f46x_utility.c hc32f46x_wdt.c
  group framework_cores
    ../source/framework/cores/: Arduino.cpp flash.cpp io.cpp iwdg.cpp Tone.cpp Tone.h
  group framework_softw
    ../source/framework/SoftwareSerial/: SoftwareSerial.cpp SoftwareSerial.h
  group framework_tmcst
    ../source/framework/TMCStepper/: TMCStepper_UTILITY.h
    ../source/framework/TMCStepper/source/: CHOPCONF.cpp COOLCONF.cpp DRV_CONF.cpp DRV_STATUS.cpp DRVCONF.cpp DRVCTRL.cpp DRVSTATUS.cpp ENCMODE.cpp GCONF.cpp IHOLD_IRUN.cpp PWMCONF.cpp RAMP_STAT.cpp SERIAL_SWITCH.cpp SERIAL_SWITCH.h SGCSCONF.cpp SHORT_CONF.cpp SMARTEN.cpp SW_MODE.cpp SW_SPI.h TMC_MACROS.h TMC_platforms.h TMC2130_bitfields.h TMC2160_bitfields.h TMC2208_bitfields.h TMC2208Stepper.cpp TMC2209_bitfields.h TMC2209Stepper.cpp TMC2660_bitfields.h TMC5130_bitfields.h TMC5160_bitfields.h TMCStepper.cpp
  group main
    ../source/main/: ddl_config.h
    ../source/main/hdsc32core/: core_cm4.h hc32_common.h hc32_ddl.h hc32f46x.h startup_hc32f46x.s stdint.h stdio.h system_hc32f46x.c system_hc32f46x.h
  group marlin
    ../source/Marlin/: Configuration.h Configuration_adv.h Version.h
    ../source/Marlin/src/: MarlinCore.cpp MarlinCore.h
  group marlin_src_core
    ../source/Marlin/src/core/: boards.h debug_out.h debug_section.h drivers.h language.h macros.h millis_t.h multi_language.h serial.cpp serial.h types.h utility.cpp utility.h
  group marlin_src_featu
    ../source/Marlin/src/feature/: actouch.cpp actouch.h babystep.cpp babystep.h bltouch.cpp bltouch.h caselight.cpp caselight.h controllerfan.cpp controllerfan.h e_parser.cpp e_parser.h fwretract.cpp fwretract.h host_actions.cpp host_actions.h pause.cpp pause.h power_monitor.cpp power_monitor.h powerloss.cpp powerloss.h repeat.cpp repeat.h runout.cpp runout.h spindle_laser_types.h tmc_util.cpp tmc_util.h z_stepper_align.cpp z_stepper_align.h
    ../source/Marlin/src/feature/bedlevel/: bedlevel.cpp bedlevel.h
  group marlin_src_featu_bedle_abl
    ../source/Marlin/src/feature/bedlevel/abl/: abl.cpp abl.h
  group marlin_src_featu_bedle_ubl
    ../source/Marlin/src/feature/bedlevel/ubl/: ubl.cpp ubl.h ubl_G29.cpp ubl_motion.cpp
  group marlin_src_gcode
    ../source/Marlin/src/gcode/: gcode.cpp gcode.h gcode_d.cpp parser.cpp parser.h queue.cpp queue.h
    ../source/Marlin/src/gcode/units/: G20_G21.cpp M82_M83.cpp M149.cpp
    ../source/Marlin/src/gcode/temp/: M104_M109.cpp M105.cpp M106_M107.cpp M140_M190.cpp M141_M191.cpp M155.cpp M303.cpp
    ../source/Marlin/src/gcode/stats/: M31.cpp M75-M78.cpp
    ../source/Marlin/src/gcode/sd/: M20.cpp M21_M22.cpp M23.cpp M24_M25.cpp M26.cpp M27.cpp M28_M29.cpp M30.cpp M32.cpp M33.cpp M34.cpp M524.cpp M808.cpp M928.cpp M1001.cpp
    ../source/Marlin/src/gcode/scara/: M360-M364.cpp
    ../source/Marlin/src/gcode/probe/: G30.cpp G31_G32.cpp G38.cpp M401_M402.cpp M851.cpp M951.cpp
    ../source/Marlin/src/gcode/motion/: G0_G1.cpp G2_G3.cpp G4.cpp G5.cpp G6.cpp G80.cpp M290.cpp
    ../source/Marlin/src/gcode/lcd/: M0_M1.cpp M73.cpp M117.cpp M145.cpp M250.cpp M300.cpp M995.cpp
    ../source/Marlin/src/gcode/host/: M16.cpp M110.cpp M113.cpp M114.cpp M115.cpp M118.cpp M119.cpp M360.cpp M876.cpp
    ../source/Marlin/src/gcode/geometry/: G17-G19.cpp G53-G59.cpp G92.cpp M206_M428.cpp
    ../source/Marlin/src/gcode/bedlevel/: G26.cpp G35.cpp G42.cpp M420.cpp
    ../source/Marlin/src/gcode/calibrate/: G28.cpp G33.cpp G34.cpp G34_M422.cpp G76_M192_M871.cpp G425.cpp M12.cpp M48.cpp M100.cpp M425.cpp M665.cpp M666.cpp M852.cpp
    ../source/Marlin/src/gcode/caselight/: M355.cpp
    ../source/Marlin/src/gcode/config/: M43.cpp M92.cpp M200-M205.cpp M217.cpp M218.cpp M220.cpp M221.cpp M281.cpp M301.cpp M302.cpp M304.cpp M305.cpp M540.cpp M575.cpp M672.cpp
    ../source/Marlin/src/gcode/control/: M3-M5.cpp M7-M9.cpp M17_M18_M84.cpp M42.cpp M80_M81.cpp M85.cpp M108_M112_M410.cpp M111.cpp M120_M121.cpp M211.cpp M226.cpp M280.cpp M350_M351.cpp M380_M381.cpp M400.cpp M605.cpp M993_M994.cpp M997.cpp M999.cpp T.cpp
    ../source/Marlin/src/gcode/eeprom/: M500-M504.cpp
    ../source/Marlin/src/gcode/feature/controllerfan/: M710.cpp
    ../source/Marlin/src/gcode/feature/digipot/: M907-M910.cpp
    ../source/Marlin/src/gcode/feature/network/: M552-M554.cpp
  group marlin_src_gcode_bedle_abl
    ../source/Marlin/src/gcode/bedlevel/abl/: G29.cpp M421.cpp
  group marlin_src_gcode_featu_advan
    ../source/Marlin/src/gcode/feature/advance/: M900.cpp
  group marlin_src_gcode_featu_pause
    ../source/Marlin/src/gcode/feature/pause/: G27.cpp G60.cpp G61.cpp M125.cpp M600.cpp M603.cpp M701_M702.cpp
  group marlin_src_gcode_featu_power
    ../source/Marlin/src/gcode/feature/powerloss/: M413.cpp M1000.cpp
    ../source/Marlin/src/gcode/feature/power_monitor/: M430.cpp
  group marlin_src_gcode_featu_runou
    ../source/Marlin/src/gcode/feature/runout/: M412.cpp
  group marlin_src_gcode_featu_trina
    ../source/Marlin/src/gcode/feature/trinamic/: M122.cpp M569.cpp M906.cpp M911-M914.cpp
  group marlin_src_hal
    ../source/Marlin/src/HAL/: HAL.h platforms.h tft_spi.cpp tft_spi.h
  group marlin_src_hal_share
    ../source/Marlin/src/HAL/shared/: Delay.h esp_wifi.cpp esp_wifi.h Marduino.h math_32bit.h servo_private.h HAL_spi_L6470.cpp HAL_ST7920.h HAL_SPI.h eeprom_api.cpp eeprom_api.h
  group marlin_src_hal_stm32
    ../source/Marlin/src/HAL/STM32/: eeprom_flash.cpp eeprom_sdcard.cpp endstop_interrupts.h fastio.cpp fastio.h HAL.cpp HAL.h sdio.cpp spi_pins.h timers.cpp timers.h watchdog.cpp watchdog.h
    ../source/Marlin/src/HAL/STM32/inc/: Conditionals_adv.h Conditionals_LCD.h Conditionals_post.h SanityCheck.h
  group marlin_src_inc
    ../source/Marlin/src/inc/: Conditionals_adv.h Conditionals_LCD.h Conditionals_post.h MarlinConfig.h MarlinConfigPre.h SanityCheck.h Version.h
  group marlin_src_lcd
    ../source/Marlin/src/lcd/: buttons.h fontutils.cpp fontutils.h lcdprint.cpp lcdprint.h marlinui.cpp marlinui.h scaled_tft.h thermistornames.h
  group marlin_src_lcd_extui
    ../source/Marlin/src/lcd/extui/: anycubic_chiron_lcd.cpp anycubic_dgus_lcd.cpp ui_api.cpp ui_api.h
    ../source/Marlin/src/lcd/extui/lib/anycubic_dgus/: dgus_FileNavigator.cpp dgus_FileNavigator.h dgus_tft.cpp dgus_tft.h dgus_tft_defs.h dgus_Tunes.cpp dgus_Tunes.h
    ../source/Marlin/src/lcd/extui/lib/anycubic_chiron/: chiron_tft.cpp chiron_tft.h chiron_tft_defs.h FileNavigator.cpp FileNavigator.h Tunes.cpp Tunes.h
  group marlin_src_lcd_langu
    ../source/Marlin/src/lcd/language/: language_an.h language_bg.h language_ca.h language_cz.h language_da.h language_de.h language_el.h language_el_CY.h language_el_gr.h language_en.h language_es.h language_eu.h language_fi.h language_fr.h language_gl.h language_hr.h language_hu.h language_it.h language_jp_kana.h language_ko_KR.h language_nl.h language_pl.h language_pt.h language_pt_br.h language_ro.h language_ru.h language_sk.h language_sv.h language_test.h language_tr.h language_uk.h language_vi.h language_zh_CN.h language_zh_TW.h
  group marlin_src_lcd_menu
    ../source/Marlin/src/lcd/menu/: menu.cpp menu.h menu_addon.h menu_advanced.cpp menu_backlash.cpp menu_bed_corners.cpp menu_bed_leveling.cpp menu_cancelobject.cpp menu_configuration.cpp menu_delta_calibrate.cpp menu_filament.cpp menu_game.cpp menu_info.cpp menu_item.h menu_job_recovery.cpp menu_language.cpp menu_led.cpp menu_main.cpp menu_media.cpp menu_mixer.cpp menu_mmu2.cpp menu_mmu2.h menu_motion.cpp menu_password.cpp menu_power_monitor.cpp menu_probe_offset.cpp menu_spindle_laser.cpp menu_temperature.cpp menu_tmc.cpp menu_touch_screen.cpp menu_tramming.cpp menu_tune.cpp menu_ubl.cpp
  group marlin_src_lcd_tft
    ../source/Marlin/src/lcd/tft/: canvas.cpp canvas.h tft.cpp tft.h tft_color.h tft_image.cpp tft_image.h tft_queue.cpp tft_queue.h tft_string.cpp tft_string.h touch.cpp touch.h ui_320x240.cpp ui_320x240.h ui_common.cpp ui_common.h ui_480x320.cpp ui_480x320.h ui_1024x600.cpp ui_1024x600.h
    ../source/Marlin/src/lcd/tft/fontdata/: helvetica_14.cpp fontdata_10x20.cpp fontdata_ISO10646_1.cpp helvetica_12_bold.cpp helvetica_18.cpp langdata_zh_CN.h profont_22.cpp
    ../source/Marlin/src/lcd/tft/images/: back_32x32x4.cpp background_320x30x16.cpp bootscreen_112x38x1.cpp bootscreen_195x59x16.cpp bootscreen_228x255x2.cpp bootscreen_228x255x4.cpp bootscreen_320x240x16.cpp bootscreen_480x320x16.cpp btn_rounded_42x39x4.cpp btn_rounded_64x52x4.cpp cancel_64x64x4.cpp chamber_64x64x4.cpp confirm_64x64x4.cpp decrease_64x64x4.cpp directory_32x32x4.cpp down_32x32x4.cpp fan_64x64x4.cpp fan_fast_64x64x4.cpp fan_slow_64x64x4.cpp feedrate_32x32x4.cpp flowrate_32x32x4.cpp heated_bed_64x64x4.cpp home_64x64x4.cpp hotend_64x64x4.cpp increase_64x64x4.cpp left_32x32x4.cpp leveling_32x32x4.cpp menu_64x64x4.cpp pause_64x64x4.cpp refresh_32x32x4.cpp right_32x32x4.cpp sd_64x64x4.cpp settings_64x64x4.cpp slider_8x16x4.cpp up_32x32x4.cpp
  group marlin_src_lcd_tft_i
    ../source/Marlin/src/lcd/tft_io/: ili9328.h ili9341.h ili9488.h r65105.h ssd1963.h st7735.h st7789v.h st7796s.h tft_ids.h tft_io.cpp tft_io.h
  group marlin_src_libs
    ../source/Marlin/src/libs/: bresenham.h buzzer.cpp buzzer.h circularqueue.h crc16.cpp crc16.h duration_t.h hex_print.cpp hex_print.h nozzle.cpp nozzle.h numtostr.cpp numtostr.h private_spi.h softspi.h stopwatch.cpp stopwatch.h vector_3.cpp vector_3.h least_squares_fit.cpp least_squares_fit.h dtostrf.cpp dtostrf.h
  group marlin_src_modul
    ../source/Marlin/src/module/: encoder.cpp endstops.cpp endstops.h HS_servo.cpp HS_servo.h motion.cpp motion.h planner.cpp planner.h printcounter.cpp printcounter.h probe.cpp probe.h servo.cpp servo.h settings.cpp settings.h speed_lookuptable.h stepper.cpp stepper.h temperature.cpp temperature.h tool_change.cpp tool_change.h
    ../source/Marlin/src/module/thermistor/: thermistors.h
    ../source/Marlin/src/module/stepper/: indirection.cpp indirection.h trinamic.cpp trinamic.h
  group marlin_src_pins
    ../source/Marlin/src/pins/: pins.h pins_postprocess.h pinsDebug.h pinsDebug_list.h sensitive_pins.h
    ../source/Marlin/src/pins/stm32f1/: pins_AC_TRI_F1_V1.h
  group marlin_src_sd
    ../source/Marlin/src/sd/: cardreader.cpp cardreader.h Sd2Card.cpp Sd2Card.h Sd2Card_sdio.h SdBaseFile.cpp SdBaseFile.h SdFatConfig.h SdFatStructs.h SdFatUtil.cpp SdFatUtil.h SdFile.cpp SdFile.h SdInfo.h SdVolume.cpp SdVolume.h
    ../source/Marlin/src/sd/usb_flashdrive/: Sd2Card_FlashDrive.cpp Sd2Card_FlashDrive.h
software components: CMSIS:CORE 5.4.0, CMSIS:DSP 1.8.0
